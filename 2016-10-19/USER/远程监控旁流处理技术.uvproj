# Keil uVision project 远程监控旁流处理技术.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: YCJKPLCLJS +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\DAC8552;..\HARDWARE\DGUS;..\HARDWARE\ADC;..\HARDWARE\OperationalCycleTime;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\DO;..\HARDWARE\LCD;..\HARDWARE\DI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DAC8552/: dac8552.c
    ../HARDWARE/DGUS/: dgus.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/OperationalCycleTime/: oct.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/DO/: do.c
    ../HARDWARE/DI/: di.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c
